<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>K</value></param>
<param><key>value</key><value>10**(lamda/(4*numpy.pi*d0))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carrier_freq</value></param>
<param><key>value</key><value>800e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d0</value></param>
<param><key>value</key><value>20.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>distance</value></param>
<param><key>value</key><value>20</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>15e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>900e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lamda</value></param>
<param><key>value</key><value>scipy.constants.c/frequency</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wavelength</value></param>
<param><key>value</key><value>scipy.constants.c/frequency</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import scipy.constants</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>carrier_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
